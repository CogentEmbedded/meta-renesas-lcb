FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_porter = 'file://EVA_SGX_KM_M2.tar.bz2'
SRC_URI_silk = 'file://EVA_SGX_KM_E2.tar.bz2'
