#Due to the gitorious.org shutdown linux-can decided to move to GitHub
SRC_URI = "git://github.com/linux-can/can-utils.git;protocol=git;branch=master"
SRCREV = "0eb1e3db2e20b0d895468363dbe6030cd8afa61c"
