FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_silk = "file://EVA_r8a7794_linux_sgx_binaries_gles2.tar.bz2"
